# Keil uVision project F107VCT6.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F107VC STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: F107VCT6
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_CL
  c misc: --no-multibyte-chars
  c include: .\Drivers\Library;.\Drivers\Start;.\FreeRTOS\portable;.\FreeRTOS\portable\ARM_CM3;.\FreeRTOS\include;.\Src;.\Inc;.\Inc\bsp
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/User
    ./Src/: main.c stm32f10x_it.c FreeRTOSConfig.h
  group Application/MDK-ARM
    ./Drivers/Start/: startup_stm32f10x_cl.s
  group bsp
    ./Src/bsp/: bsp_485.c bsp_Delay.c bsp_Motor.c bsp_PWM.c bsp_Serial.c Limit.c OLED.c
    ./Inc/: FreeRTOS_Demo.h
    ./Src/: FreeRTOS_Demo.c
  group Readme
    ./Readme/: 01.开发环境说明.txt
  group Drivers/Core
    ./Drivers/Start/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group Drivers/Library
    ./Drivers/Library/: misc.c misc.h stm32f10x_adc.c stm32f10x_adc.h stm32f10x_bkp.c stm32f10x_bkp.h stm32f10x_can.c stm32f10x_can.h stm32f10x_cec.c stm32f10x_cec.h stm32f10x_crc.c stm32f10x_crc.h stm32f10x_dac.c stm32f10x_dac.h stm32f10x_dbgmcu.c stm32f10x_dbgmcu.h stm32f10x_dma.c stm32f10x_dma.h stm32f10x_exti.c stm32f10x_exti.h stm32f10x_flash.c stm32f10x_flash.h stm32f10x_fsmc.c stm32f10x_fsmc.h stm32f10x_gpio.c stm32f10x_gpio.h stm32f10x_i2c.c stm32f10x_i2c.h stm32f10x_iwdg.c stm32f10x_iwdg.h stm32f10x_pwr.c stm32f10x_pwr.h stm32f10x_rcc.c stm32f10x_rcc.h stm32f10x_rtc.c stm32f10x_rtc.h stm32f10x_sdio.c stm32f10x_sdio.h stm32f10x_spi.c stm32f10x_spi.h stm32f10x_tim.c stm32f10x_tim.h stm32f10x_usart.c stm32f10x_usart.h stm32f10x_wwdg.c stm32f10x_wwdg.h
  group FreeRTOS/source
    ./FreeRTOS/source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/port
    ./FreeRTOS/portable/: heap_4.c
    ./FreeRTOS/portable/ARM_CM3/: port.c portmacro.h
